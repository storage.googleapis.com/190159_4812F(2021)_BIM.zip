Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-12-18T13:52:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 18 13:52:32 2020 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{3137A0DD-289D-4313-8D8F-0CA3DD3A7B7C}\ifc * Database version: 5507 * Database creation date: Fri Dec 18 13:52:31 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 18 13:52:31 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 18 13:52:31 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 4812F Washbasin faucet, 4812F(2021):4812F Washbasin faucet:396475
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 143.806 mm; FaucetNominalHeight: 175.838 mm; FaucetNominalWidth: 48.5 mm; HandShowerNominalDepth: 68.5 mm; HandShowerNominalHeight: 314.727 mm; HandShowerNominalWidth: 57 mm; InletConnectionSize: 10 mm; Projection: 113 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 4812F(2021); ConvergoRefNr: 0087-2012-0005-FI; ManufacterURL: www.hansa.com; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for washbasins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 16/12/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: HC; Customs Code: 84818011; EAN Number: 6414150097041; EN Standard: EN 817; LVI Number: 6110347; VVS Number: 703964104
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/4812F; Catalog Drawing URL: http://static.oras.com/catdrw/4812F; Class: Single lever;Bidetta; Dimension Drawing URL: http://static.oras.com/dimdrw/4812F; FDV Document URL: http://www.oras.com/datasheet/4812F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/4812F; Group: Washbasin faucets; Manufacturer: Hansa; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 4812F Washbasin faucet; Name_en: 4812F Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 585 x 225 x 95; Product Code: 4812F; Product Datasheet: http://www.oras.com/datasheet/4812F/en; Product data url: https://www.bimobject.com/hansa/product/51342201; Product Family: Oras Stela; Product Image URL: http://static.oras.com/image/4812F; Product URL: http://static.oras.com/4812F; Technical DataSheet URL: http://www.oras.com/datasheet/4812F/en; Type Name: 4812F Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass;3S-Installation; Aerator: Laminar; Connection: FlexibleInletPipes; Connection Size: G3/8; Flow Rate At 300kPa: 0.00317832 m3/s; Installation and Maintenance: http://static.oras.com/manual/4812F; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1MountingHole; Noise Class: I (ISO 3822); Not Included: WithoutPopupWaste; Spare Parts: http://static.oras.com/sp/4812F; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 4812F(2021); Features: Single lever;Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 4812F; Name: 4812F Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x175x145 mm / Hand shower: 55x70x315 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 4812F; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 4812F Washbasin faucet
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0852915 m2; Volume: 0.00245996 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 4812F(2021): 4812F Washbasin faucet; Family and Type: 4812F(2021): 4812F Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 4812F(2021): 4812F Washbasin faucet; Type Id: 4812F(2021): 4812F Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
